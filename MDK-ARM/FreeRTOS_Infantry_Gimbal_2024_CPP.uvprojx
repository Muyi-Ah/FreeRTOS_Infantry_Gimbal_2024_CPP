# Keil uVision project FreeRTOS_Infantry_Gimbal_2024_CPP.uvprojx, settings and files
target FreeRTOS_Infantry_Gimbal_2024_CPP (6220000::V6.22::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: FreeRTOS_Infantry_Gimbal_2024_CPP +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../../../../AppData/Local/Keil_v5/ARM/ARMCLANG/include;../bsp;../src/component;../src/device/CH110;../src/device/DR16;../src/device/motor;../src/filter;../utils;../src;../../../../AppData/Local/Arm/Packs/ARM/CMSIS-DSP/1.15.0/Include
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group bsp
    ../bsp/: bsp_can.cpp bsp_uart.cpp
  group src
    ../src/: gimbal.cpp init.cpp timer_callback.cpp
  group src/component
    ../src/component/: communication.cpp pid.cpp state_machine.cpp ude.cpp vision.cpp vofa.cpp gravity_compensation.cpp
  group src/device
    ../src/device/CH110/: ch110.cpp
    ../src/device/DR16/: dr16.cpp
    ../src/device/motor/: DJI_motor.cpp
  group src/filter
    ../src/filter/: LPF.cpp
  group utils
    ../utils/: clamp.cpp crc.cpp error_handle.cpp verify.cpp simple_math.cpp
software components: CMSIS:CORE 6.1.0, CMSIS:DSP 1.15.0
